# Keil uVision project Firmware.uvprojx, settings and files
target Firmware (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: Firmware +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F746xx ST STM32F756xx USE_FREERTOS_8 USE_OS_SYSTICK USE_STM32746G_DISCOVERY USE_BPP=16
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Drivers/CMSIS/Include;..\..\Graphic\gui\include;..\..\Graphic\platform\os;..\..\Graphic\generated\fonts\include;..\..\Graphic\generated\images\include;..\..\Graphic\generated\texts\include;..\..\..\..\touchgfx\framework\include;..\..\..\..\touchgfx\os\FreeRTOS8.2.0\Source\include;..\..\..\..\touchgfx\os\FreeRTOS8.2.0\Source\portable\RVDS\ST_CM7;..\..\..\..\touchgfx\board\ST\STM32F746G-DISCO\include;..\..\..\..\touchgfx\board\ST\STM32F746G-DISCO\source\vendor\STM32746G-Discovery;..\..\Graphic\gui\include\gui\common
  asm include: ..\..\..\..\touchgfx\os\FreeRTOS8.2.0\Source\include;..\..\..\..\touchgfx\os\FreeRTOS8.2.0\Source\portable\MemMang
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: ..\Flash_QSPI.sct
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Gui
    ../../Graphic/gui/src/common/: ChannelControlPanel.cpp CustomListElement.cpp FrontendApplication.cpp Graph.cpp Marker.cpp TriggerLine.cpp AppContext.cpp
    ../../Graphic/gui/src/main_screen/: MainPresenter.cpp MainView.cpp
    ../../Graphic/gui/src/model/: Model.cpp
  group TouchGFXHAL
    ../../../../touchgfx/board/ST/STM32F746G-DISCO/source/: BoardConfiguration.cpp GPIO.cpp
    ../../../../touchgfx/board/ST/STM32F746G-DISCO/source/bsp/: STM32F7Instrumentation.cpp STM32F746GTouchController.cpp
    ../../../../touchgfx/framework/source/platform/hal/ST/mcu/stm32f7xx/: STM32F7DMA.cpp STM32F7HAL.cpp
  group OS
    ../../../../touchgfx/os/FreeRTOS8.2.0/: OSWrappers.cpp
    ../../../../touchgfx/os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../../../touchgfx/os/FreeRTOS8.2.0/Source/portable/RVDS/ST_CM7/: port.c
    ../../../../touchgfx/os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_2.c
  group Library
    ../../../../touchgfx/lib/core/cortex_m7/Keil/: touchgfx_core.lib
  group BSP
    ../../../../touchgfx/board/ST/STM32F746G-DISCO/source/vendor/STM32746G-Discovery/: stm32746g_discovery.c stm32746g_discovery_lcd.c stm32746g_discovery_sd.c stm32746g_discovery_sdram.c stm32746g_discovery_ts.c stm32746g_discovery_qspi.c
    ../../../../touchgfx/board/ST/STM32F746G-DISCO/source/vendor/Components/ft5336/: ft5336.c
  group Application/User
    ../Src/: stm32f7xx_hal_msp.c stm32f7xx_it.c settings.c
    ./: main.cpp
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_pwr.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_dma.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal.c stm32f7xx_hal_flash.c stm32f7xx_hal_tim.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_adc.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_qspi.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spi.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_uart.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_sd.c
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Generated
    ../../Graphic/generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
    ../../Graphic/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_Asap_Regular_12_4bpp_0.cpp Font_Asap_Regular_13_4bpp_0.cpp Font_Asap_Regular_14_8bpp_0.cpp Font_Asap_Regular_18_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_Asap_Regular_12_4bpp.cpp Kerning_Asap_Regular_13_4bpp.cpp Kerning_Asap_Regular_14_8bpp.cpp Kerning_Asap_Regular_18_4bpp.cpp Table_Asap_Regular_12_4bpp.cpp Table_Asap_Regular_13_4bpp.cpp Table_Asap_Regular_14_8bpp.cpp Table_Asap_Regular_18_4bpp.cpp UnmappedDataFont.cpp
    ../../Graphic/generated/images/src/: BitmapDatabase.cpp image_appBackground.cpp image_button_background.cpp image_buttonDownOff.cpp image_buttonDownOn.cpp image_buttonUpOff.cpp image_buttonUpOn.cpp image_channel1.cpp image_channel2.cpp image_channelInfo_ch1.cpp image_channelInfo_ch2.cpp image_ChnControlButtonOff.cpp image_ChnControlButtonOn.cpp image_controlPanel.cpp image_counterbox.cpp image_direction_background.cpp image_EdgeDown.cpp image_EdgeUp.cpp image_leftButtonPress.cpp image_leftButtonUnpress.cpp image_ozibackground.cpp image_rightButtonPress.cpp image_rightButtonUnpress.cpp image_sideslidebutton.cpp image_sideslidebutton_press.cpp image_slideMenu.cpp image_text_background.cpp image_VChnControlButtonOff.cpp image_VChnControlButtonOn.cpp image_EdgeDown_off.cpp image_EdgeUp_off.cpp image_intro.cpp image_channel_info.cpp image_chLeftButtonPress.cpp image_chLeftButtonUnpress.cpp image_chRightButtonPress.cpp image_chRightButtonUnpress.cpp image_ch1_off.cpp image_ch1_on.cpp image_ch2_off.cpp image_ch2_on.cpp image_control_template.cpp image_cursor_off.cpp image_cursor_on.cpp image_measure_off.cpp image_RUN.cpp image_stop.cpp image_cursor_on_ch1.cpp image_cursor_on_ch2.cpp image_reset_settings_press.cpp image_reset_settings_unpress.cpp image_save_settings_press.cpp image_save_settings_unpress.cpp image_button_template.cpp image_trig_marker_off.cpp image_trig_marker_on.cpp image_control_signal_off.cpp image_control_signal_on.cpp image_sine_signal.cpp image_square_signal.cpp image_signal_1KHZ.cpp image_signal_10KHZ.cpp
software components: CMSIS:CORE 4.1.0
